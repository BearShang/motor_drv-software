<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bldc_1shunt_hall_sensor.ewp</path>
    </project>
    <batchBuild />
</workspace>
