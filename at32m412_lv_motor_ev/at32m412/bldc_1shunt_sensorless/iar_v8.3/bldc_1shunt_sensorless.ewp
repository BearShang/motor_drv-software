# IAR project bldc_1shunt_sensorless.ewp, settings and files
configuration bldc_1shunt_sensorless (ARM, debug)
  General.OGChipSelectEditMenu: AT32M412CBT7_v2 ArteryTek AT32M412CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32M412CBT7; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../../../../mclib/inc; ../inc; ../../../../libraries/AT32M412_416_Firmware_Library/drivers/inc; ../../../../libraries/AT32M412_416_Firmware_Library/cmsis/cm4/core_support; ../../../../libraries/AT32M412_416_Firmware_Library/cmsis/cm4/device_support
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: AT32M412xB_mcdata.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ../../../../libraries/AT32M412_416_Firmware_Library/cmsis/cm4/device_support/startup/iar/: startup_at32m412_416.s
    ../../../../libraries/AT32M412_416_Firmware_Library/cmsis/cm4/device_support/: system_at32m412_416.c
  group firmware
    ../../../../libraries/AT32M412_416_Firmware_Library/drivers/src/: at32m412_416_adc.c at32m412_416_can.c at32m412_416_cmp.c at32m412_416_crc.c at32m412_416_crm.c at32m412_416_dac.c at32m412_416_debug.c at32m412_416_dma.c at32m412_416_ertc.c at32m412_416_exint.c at32m412_416_flash.c at32m412_416_gpio.c at32m412_416_i2c.c at32m412_416_misc.c at32m412_416_op.c at32m412_416_pwc.c at32m412_416_scfg.c at32m412_416_spi.c at32m412_416_tmr.c at32m412_416_usart.c at32m412_416_wdt.c at32m412_416_wwdt.c
  group mclib
    ../../../../mclib/src/: mc_bldc.c mc_bldc_esc_state_sensorless.c mc_bldc_globals.c mc_bldc_kernal.a mc_bldc_sensorless.c mc_comm_uart.c mc_curr_fdbk.c mc_delay.c mc_flash_data_table_bldc.c mc_math.c mc_pid_controller.c motor_control_bldc.c user_interface_bldc.c
  group user
    ../src/: at32m412_416_clock.c at32m412_416_int.c main.c mc_hwio.c mc_isr.c
    ../inc/: mc_hwio_v1_0.h mc_lib.h motor_control_drive_param.h motor_control_drive_param_A2212KV2700_M412.h
