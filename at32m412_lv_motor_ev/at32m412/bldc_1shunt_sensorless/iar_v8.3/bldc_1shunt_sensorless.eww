<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bldc_1shunt_sensorless.ewp</path>
    </project>
    <batchBuild />
</workspace>
