# Keil uVision project bldc_1shunt_sensorless.uvprojx, settings and files
target bldc_1shunt_sensorless (6190000::V6.19::ARMCLANG)
  device: AT32M412KBU7-4 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bldc_1shunt_sensorless +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32M412KBU7_4,USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\mclib\inc;..\inc;..\..\..\..\libraries\AT32M412_416_Firmware_Library\drivers\inc;..\..\..\..\libraries\AT32M412_416_Firmware_Library\cmsis\cm4\core_support;..\..\..\..\libraries\AT32M412_416_Firmware_Library\cmsis\cm4\device_support;..\..\..\..\libraries\AT32M412_416_Firmware_Library\cmsis\dsp\include;..\..\..\..\libraries\AT32M412_416_Firmware_Library\cmsis\dsp\PrivateInclude
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1fc00
  memory RVCT5: ROM 0x801fc00 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32m412_416_clock.c at32m412_416_int.c main.c mc_isr.c mc_hwio.c
    ../inc/: mc_lib.h motor_control_drive_param.h mc_hwio_m412_lv_v1_0.h
  group firmware
    ../../../../libraries/AT32M412_416_Firmware_Library/drivers/src/: at32m412_416_adc.c at32m412_416_can.c at32m412_416_cmp.c at32m412_416_crc.c at32m412_416_crm.c at32m412_416_dac.c at32m412_416_debug.c at32m412_416_dma.c at32m412_416_ertc.c at32m412_416_exint.c at32m412_416_flash.c at32m412_416_gpio.c at32m412_416_i2c.c at32m412_416_misc.c at32m412_416_op.c at32m412_416_pwc.c at32m412_416_scfg.c at32m412_416_spi.c at32m412_416_tmr.c at32m412_416_usart.c at32m412_416_wdt.c at32m412_416_wwdt.c
  group cmsis
    ../../../../libraries/AT32M412_416_Firmware_Library/cmsis/cm4/device_support/: system_at32m412_416.c
    ../../../../libraries/AT32M412_416_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32m412_416.s
  group mclib
    ../../../../mclib/src/: mc_delay.c mc_curr_fdbk.c mc_bldc.c mc_comm_uart.c mc_pid_controller.c mc_bldc_globals.c mc_math.c mc_bldc_sensorless.c user_interface_bldc.c motor_control_bldc.c mc_flash_data_table_bldc.c mc_bldc_esc_state_sensorless.c mc_bldc_kernal.lib
