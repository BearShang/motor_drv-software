<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pmsm_foc_sensorless.ewp</path>
  </project>
  <batchBuild/>
</workspace>
